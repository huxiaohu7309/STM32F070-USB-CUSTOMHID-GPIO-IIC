# Keil uVision project STM32F070-USB-CUSTOMHID-GPIO-IIC.uvprojx, settings and files
target STM32F070-USB-CUSTOMHID-GPIO-IIC (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F070F6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F070-USB-CUSTOMHID-GPIO-IIC
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F070x6
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Application/MDK-ARM
    ./: startup_stm32f070x6.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_core.c usbd_ctlreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Src/: usbd_customhid.c
  group Application/User
    ../Src/: stm32f0xx_it.c usb_device.c usbd_custom_hid_if.c main.c usbd_desc.c usbd_conf.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_gpio.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_flash.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal.c stm32f0xx_hal_rcc.c stm32f0xx_hal_tim.c stm32f0xx_hal_pwr.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f0xx.c
software components: CMSIS:CORE 4.3.0
